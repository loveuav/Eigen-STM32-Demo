# Keil uVision project Eigen-STM32-Demo.uvprojx, settings and files
target Eigen-STM32-Demo (6120000::V6.12::.\ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Eigen-STM32-Demo +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ..\PROJECT;..\Eigen;..\Driver\STM32F4xx_HAL_Driver\Inc;..\Driver\STM32F4xx_HAL_Driver\Inc\Legacy;..\Driver\CMSIS\Device\ST\STM32F4xx\Include;..\Driver\CMSIS\Include;..\Driver\STM32F4xx_HAL_Driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SYSTEM
    ../Src/: main.cpp retarget.c
  group STM32F4xx_HAL_Driver
    ../Driver/STM32F4xx_HAL_Driver/Startup/MDK/: startup_stm32f40_41xxx.s
    ../Driver/STM32F4xx_HAL_Driver/: system_stm32f4xx.c
    ../Driver/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c
